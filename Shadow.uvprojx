# Keil uVision project Shadow.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Shadow +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Shadow.s general.s Health.s left.s Right.s Health_2.s GameOver.s StartScreen.s
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
